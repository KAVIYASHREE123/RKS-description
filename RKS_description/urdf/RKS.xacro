Commit message: Update RKS.xacro

File: RKS_description/urdf/RKS.xacro (robot description, xacro)
@@ -74,5 +74,5 @@
   <parent link="base_link"/>
   <child link="left__wheel__1__1"/>
-  <axis xyz="-0.0 -1.0 -0.0"/>
+  <axis xyz="-0.0 1.0 0.0"/>
 </joint>
 </robot>
